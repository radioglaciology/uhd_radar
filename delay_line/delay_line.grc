options:
  parameters:
    generate_options: qt_gui
    id: delay_line
    output_language: python
  states: {}

blocks:
- name: delay_sec
  id: variable_qtgui_range
  parameters:
    label: Delay
    start: '0'
    step: '0.0001'
    stop: '0.0005'
    value: '0.0003'
    widget: slider
  states: {}
- name: device_addr
  id: variable
  parameters:
    value: '"serial=312A195"'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 435e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 16e6
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int(delay_sec*samp_rate)
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '256'
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: samp_rate
    center_freq0: freq
    clock_rate: '0.0'
    dev_addr: device_addr
    dev_args: '""'
    gain0: '50'
    len_tag_name: ''
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: samp_rate
    center_freq0: freq
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_addr: device_addr
    dev_args: '""'
    gain0: '55'
    iq_imbal_enb0: '""'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_delay_0, '0', uhd_usrp_sink_0, '0']
- [uhd_usrp_source_0, '0', blocks_delay_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
